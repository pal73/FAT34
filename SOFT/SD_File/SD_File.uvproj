# Keil uVision project SD_File.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F100R4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Initialization
    ./: STM32_Init.c
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: STM32F10x.s File_Config.c SPI_STM32F103.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
